* HMK325C7475_MHPE     SPICE MODEL  ( General Type )
*--------------------------------------------------------------------------------------------------------
* Model Generated by TAIYO YUDEN Corporation (http://www.ty-top.com)
* Version 1.0
* TAIYO YUDEN Control No. 170508_161201
* Copyright(c) 2016 TAIYO YUDEN CO.,LTD. All Rights Reserved.
*--------------------------------------------------------------------------------------------------------
*
* Products Name : Multilayer Ceramic Capacitors
*
* Characteristics :
*     Capacitance : 4.7 uF , Rated Voltage : 100V , TCC : X7S
*     Case Size : 3.2 x 2.5 / 0.126 x 0.098 [mm/inch] , Thickness : 2.5 / 0.098 [mm/inch]
*     (Conditions: Temperature = 25 degC , DC Bias Current/Voltage = 0A / 0V)
*
* Frequency Range : 40Hz - 3GHz
*
* External Node Assignments :
*
*  1  o---| |---o  2
*
*--------------------------------------------------------------------------------------------------------
.SubCkt HMK325C7475_MHPE 1 2
****************************
C0 1 110 4.4316u
Cm 1 101 0.092208u
C1 101 102 0.30326u
Rc1 101 102 2.7889k
C2 102 103 0.12485u
Rc2 102 103 660.9
C3 103 110 0.020655u
Rc3 103 110 58.695
C2m 1 301 0.12466u
C21 301 302 0.66584u
Rc21 301 302 6.7693k
C22 302 303 0.58746u
Rc22 302 303 6.0424k
C23 303 304 0.58282u
Rc23 303 304 4.592k
C24 304 305 0.30169u
Rc24 304 305 911.63
C25 305 306 0.28686u
Rc25 305 306 762.01
C26 306 307 0.11074u
Rc26 306 307 144.56
C27 307 308 0.082832u
Rc27 307 308 119.83
C28 308 309 0.26798u
Rc28 308 309 36.747
C29 309 110 593.21p
Rc29 309 110 34.448
Rp0 1 110 21.2765957446809Meg
L0 110 120 0.17249n
Lm 120 130 0.38531n
L1 120 121 1.483p
RL1 121 130 30.307
L2 120 122 0.79146n
RL2 122 130 0.23725
L3 120 123 53.217n
RL3 123 130 0.10986
CR 120 124 0.35485u
LR 124 125 1.3345n
RR 125 130 55.642m
CL 130 140 99.459p
LL 130 140 0.086859n
RL 130 140 2.6427
Rs 140 2 3.3569m
****************************
.ends HMK325C7475_MHPE
